options:
  parameters:
    author: bill
    generate_options: qt_gui
    id: collect_data
    output_language: python
    title: Collect Data
  states: {}

blocks:
- name: d
  id: variable
  parameters:
    value: '0'
  states: {}
- name: enabled
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: x
  id: variable
  parameters:
    value: '0'
  states: {}
- name: y
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: ./results/str(d)+str(x).zfill(2)+str(y).zfill(2)
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100000'
    max_iter: '4000'
    scale: 1/100000
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_decimator_0
  id: blocks_stream_to_vector_decimator
  parameters:
    sample_rate: samp_rate
    type: complex
    vec_rate: '30'
    vlen: '1'
  states: {}
- name: nfc_controlled_splitter_0
  id: nfc_controlled_splitter
  parameters:
    number_of_samples_to_take: '10000000'
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    center_freq0: 5.65e6
    clock_source0: external
    gain0: '10'
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: none
    type: fc32
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: pressed
    type: int
    value: '1'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_stream_to_vector_decimator_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_decimator_0, '0', blocks_complex_to_mag_squared_0, '0']
- [nfc_controlled_splitter_0, '0', blocks_moving_average_xx_0, '0']
- [nfc_controlled_splitter_0, '1', blocks_file_sink_0, '0']
- [nfc_controlled_splitter_0, msg_out, blocks_message_debug_0, print]
- [nfc_controlled_splitter_0, msg_out, qtgui_ledindicator_0, state]
- [uhd_usrp_source_0, '0', nfc_controlled_splitter_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, blocks_message_debug_0, print]
- [variable_qtgui_msg_push_button_0, pressed, nfc_controlled_splitter_0, enable]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
