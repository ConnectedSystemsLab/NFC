options:
  parameters:
    author: bill
    generate_options: qt_gui
    id: collect_data
    output_language: python
    title: Collect Data
  states: {}

blocks:
- name: d
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: x
  id: variable
  parameters:
    value: '[[10,10],[20,20],[30,30],[20,10]]'
  states: {}
- name: y
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: '''results/''+str(y)'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: y
  states: {}
- name: nfc_arduino_0
  id: nfc_arduino
  parameters:
    port: /dev/ttyACM1
  states: {}
- name: nfc_controlled_splitter_0
  id: nfc_controlled_splitter
  parameters:
    number_of_samples_to_take: '3000000'
  states: {}
- name: nfc_index_increment_0
  id: nfc_index_increment
  parameters:
    parametername_replace_me: You need to fill in your grc/nfc_index_increment.block.yaml
    target: x
  states: {}
- name: nfc_series_reader_0
  id: nfc_series_reader
  parameters:
    target: x
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 5.95e6
    fftsize: '32768'
    type: complex
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 0,1,1,1
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    center_freq0: 5.95e6
    clock_source0: external
    gain0: '10'
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: none
    type: fc32
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 0,0,1,1
    msgName: pressed
    type: int
    value: '1'
  states: {}

connections:
- [nfc_arduino_0, finished, blocks_msgpair_to_var_0, inpair]
- [nfc_arduino_0, finished, nfc_controlled_splitter_0, enable]
- [nfc_controlled_splitter_0, '0', qtgui_freq_sink_x_0, '0']
- [nfc_controlled_splitter_0, '1', blocks_file_sink_0, '0']
- [nfc_controlled_splitter_0, msg_out, blocks_message_debug_0, print]
- [nfc_controlled_splitter_0, msg_out, nfc_index_increment_0, trigger]
- [nfc_controlled_splitter_0, msg_out, nfc_series_reader_0, trigger]
- [nfc_controlled_splitter_0, msg_out, qtgui_ledindicator_0, state]
- [nfc_series_reader_0, value, blocks_message_debug_0, print]
- [nfc_series_reader_0, value, nfc_arduino_0, position]
- [uhd_usrp_source_0, '0', nfc_controlled_splitter_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, blocks_message_debug_0, print]
- [variable_qtgui_msg_push_button_0, pressed, nfc_controlled_splitter_0, enable]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
